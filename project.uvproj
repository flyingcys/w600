# Keil uVision project project.uvproj, settings and files
target RT-Thread w600 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: rtthread-w600
  AfterMake: fromelf --bin !L --output rtthread.bin
  AfterMake: .\makeimg.bat
  c flags: Optim=4
  c define: RT_USING_ARM_LIBC, WM_W600
  c misc: --c99 --gnu
  c include: applications;.;drivers;Libraries;Libraries\Include;Libraries\Include\Driver;Libraries\Include\OS;Libraries\Include\Platform;Libraries\Include\OS;Libraries\Include\WiFi;Libraries\Platform\Inc;Libraries\Platform\Common\crypto;Libraries\Platform\Common\crypto\digest;Libraries\Platform\Common\crypto\math;Libraries\Platform\Common\crypto\symmetric;packages\netutils-latest\iperf;packages\netutils-latest\netio;packages\netutils-latest\ntp;packages\netutils-latest\ping;packages\netutils-latest\tcpdump;packages\optparse-v1.0.0;..\..\include;..\..\libcpu\arm\cortex-m3;..\..\libcpu\arm\common;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\wlan;..\..\components\finsh;..\..\components\libc\compilers\armlibc;..\..\components\net\lwip-2.0.2\src;..\..\components\net\lwip-2.0.2\src\include;..\..\components\net\lwip-2.0.2\src\include\ipv4;..\..\components\net\lwip-2.0.2\src\arch\include;..\..\components\net\lwip-2.0.2\src\include\netif;..\..\components\net\sal_socket\include;..\..\components\net\sal_socket\include\socket;..\..\components\net\sal_socket\impl;..\..\components\net\sal_socket\include\dfs_net;..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\components\net\sal_socket\include\socket\sys_socket
  library: MicroLIB
  memory RVCT4: ROM 0x8010100 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x38000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: main.c
  group Drivers
    drivers/: board.c drv_uart.c drv_wifi.c drv_pin.c
  group Libraries
    Libraries/Platform/Drivers/cpu/: wm_cpu.c
    Libraries/Platform/Drivers/gpio/: wm_gpio.c wm_gpio_afsel.c
    Libraries/Platform/Drivers/io/: wm_io.c
    Libraries/Platform/Drivers/irq/: wm_irq.c
    Libraries/Platform/Drivers/efuse/: wm_efuse.c
    Libraries/Platform/Drivers/internalflash/: wm_internal_fls.c
    Libraries/Platform/Drivers/spi/: wm_hostspi.c
    Libraries/Platform/Drivers/flash/: wm_fls.c wm_fls_gd25qxx.c
    Libraries/Platform/Drivers/dma/: wm_dma.c
    Libraries/Platform/Drivers/timer/: wm_timer.c
    Libraries/Platform/Common/Params/: wm_param.c
    Libraries/Platform/Common/crypto/: wm_crypto_hard.c
    Libraries/Platform/Common/crypto/digest/: hmac.c md2.c md4.c sha224.c sha384.c sha512.c
    Libraries/Platform/Common/crypto/keyformat/: asn1.c base64.c x509.c
    Libraries/Platform/Common/crypto/math/: pstm_mul_comba.c
    Libraries/Platform/Common/crypto/prng/: prng.c yarrow.c
    Libraries/Platform/Common/crypto/pubkey/: dh.c ecc.c pkcs.c pubkey.c rsa.c
    Libraries/Platform/Common/crypto/symmetric/: aesGCM.c des3.c idea.c rc2.c seed.c
    Libraries/rtthread/: rtthread_patch.c
    Libraries/rtthread/utils/: utils.c
    Libraries/rtthread/startup/armcc/: startup_venus.s
    Libraries/Platform/Boot/armcc/: misc.c
    Libraries/Lib/Wlan/: wlan.lib
  group NetUtils
    packages/netutils-latest/iperf/: iperf.c
    packages/netutils-latest/netio/: netio.c
    packages/netutils-latest/ntp/: ntp.c
    packages/netutils-latest/ping/: ping.c
    packages/netutils-latest/tcpdump/: tcpdump.c
  group optparse
    packages/optparse-v1.0.0/: optparse.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
  group lwIP
    ../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group SAL
    ../../components/net/sal_socket/src/: sal_ipaddr.c sal_socket.c
    ../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal_socket/impl/: af_inet_lwip.c
    ../../components/net/sal_socket/dfs_net/: dfs_net.c
